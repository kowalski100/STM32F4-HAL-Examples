# Keil uVision project Timer-Output-Compare.uvprojx, settings and files
target STM32F407-Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Timer-Output-Compare +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: .\;..\STM32Cube_FW_F4_V1.19.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\STM32Cube_FW_F4_V1.19.0\Drivers\CMSIS\Include;..\STM32Cube_FW_F4_V1.19.0\Drivers\STM32F4xx_HAL_Driver\Inc;..\STM32Cube_FW_F4_V1.19.0\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;.\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./Source/: stm32f4xx_it.c main.c
  group HAL Drivers
    ../STM32Cube_FW_F4_V1.19.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
